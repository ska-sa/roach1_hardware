* PSpice Model Editor - Version 10.2.0

*$
.SUBCKT ADA4841 INV NINV OUT VCC VEE
*
* Version 070203
* Generated by Interface Technologies
* www.i-t.com
*
D_D_VEEclamp         VEEVNBAT 10 DN
E_EOS1         NINV 93 POLY(1) CMRERR 100 0.0 1
R_RC2         VCC_INT V6 RCOLD 61.7
Q_Q1         V5 92 7 NPN
R_RP3         MAINP2 100 RCOLD 100
I_I4         100 ISUPP2 DC .6m
R_RCM2         VINMID INV RCOLD 1000MEG
D_DN1         35 36 DEN
Q_Q2         V6 INV 8 NPN
R_RCMR1         CMR_SET 100 RCOLD 1
D_D9         ISUPP2 VEE DNOM
G_G2         100 10A 10 100 1e-2
R_Rout         80 81 RCOLD 30
D_DN4         94 95 DIN
E_E1         100 0 103 0 1
C_CCM2a         100 CMRRP1  7.9577e-15
G_GV         100 15 V6 V5 .001
V_VL1         82 81 .089
L_LCM         31 30  9.8931e-4
V_VN3         0 93A 2
I_I2         ISUPP1 100 DC .6m
R_RP1         10 100 RCOLD 1e6
R_RC1         VCC_INT V5 RCOLD 61.7
D_D11         83 MAINP2 DILIM
E_DIFF1         CMRERR 0 VALUE {V(CMR_SET,VINMID)}
G_GN1         0 NINV 94 0 3.3u
D_DN5         96 97 DIN
C_CCM3         100 CMRRP2  7.9577e-15
R_R4         100 ISUPP2 RCOLD 10meg
E_E5         VEE_INT 0 VEE 0 1
E_E7         CMR_SET 100 VALUE { Limit(V(VINMID, 100), -5.1, 4) }
E_E4         VCC_INT 0 VCC 0 1
V_VN5         0 96 2
R_RCM4         CMRR_V 100 RCOLD 100
E_ENIN         92 9 36 0 5.25
C_COPOUT         100 81  2p
R_R3         ISUPP1 100 RCOLD 10meg
E_E6         103 VEE_INT VALUE { (V(VCC_INT)-V(VEE_INT))/2 }
V_VN2         37 0 3Vdc
C_CP1         100 10  3.98e-9
R_RCM1b         31 100 RCOLD 4
G_G3a         100 MAINP2 10A 100 1e-2
R_R5         100 CMRERR RCOLD 1k
L_Lout         OUT 81  2u
V_VN6         98 0 2
R_RCM2a         CMRRP1 100 RCOLD 100
G_G4         100 ISUPP2 80 81 -.033
D_D10         MAINP2 82 DILIM
R_RE2         8 4 RCOLD 10
R_RCM3         CMRRP2 100 RCOLD 100
C_CP2         100 10A  1.59e-11
D_DN2         36 37 DEN
E_EOS         93 9 POLY(1) CMRR_V 100 0.0 1
D_D8         VCC ISUPP1 DNOM
G_G10         0 INV 97 0 3.3u
G_G8         100 CMRR_V CMRRP2 100 .01
R_RE1         7 4 RCOLD 10
D_DN6         97 98 DIN
C_CP3         100 100  10e-13
G_G7         100 CMRRP2 CMRRP1 100 .01
D_D7         ISUPP2 100 DZ
G_G1         100 10 15 100 1e-2
V_VP         VCC_INT VCCVPBAT .57
G_G6         100 CMRRP1 30 100 .01
D_DN3         93A 94 DIN
R_RV         15 100 RCOLD 100k
E_EBUF         80 100 MAINP2 100 1
R_RCM1         NINV VINMID RCOLD 1000MEG
D_DZ1         15 16 DLIM
D_D6         100 ISUPP1 DZ
C_CCM4         100 CMRR_V  1.9894e-15
D_D_VCCclamp         10 VCCVPBAT DP
V_VL2         81 83 1.1
V_VN1         0 35 3Vdc
I_I1         4 VEE_INT DC 1e-3
R_RCM2b         30 31 RCOLD 8.56e4
V_VN         VEEVNBAT VEE_INT .57
D_DZ2         100 16 DLIM
G_G5         100 30 VINMID 100 8.162e-7
G_G3         ISUPP1 100 80 81 .033
V_VN4         95 0 2
R_RP2         10A 100 RCOLD 1e2
.MODEL DLIM D(IS=1E-15 BV=4.452)
.MODEL DEN  D(IS=1E-8 RS=1 KF=1.5E-15 AF=1.2)
.MODEL DIN  D(IS=.75E-12 RS=1000 KF=1.5E-16 AF=1.06)
.MODEL	DNOM	D(IS=1E-15 T_ABS=-100)
.MODEL	DZ	D(IS=1E-15 BV=50 T_ABS=-100)
.MODEL  RCOLD	RES T_ABS=-273
.MODEL 	DILIM	D(IS=1E-15)
.MODEL NPN  NPN(BF=1.52e2)
.MODEL	DP	D(IS=5E-10 BV=700 )
.MODEL	DN	D(IS=5E-10 BV=700 )
.MODEL DCMRP D(IS=1E-15 BV=2)
.MODEL DCMRM D(IS=1E-15 BV=4.6)
.ENDS
*$
