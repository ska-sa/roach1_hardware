| IBIS file k7x32xxxxc_hstl_r00.ibs created by s2ibis2 version 1.111
| North Carolina State University Electronics Research Laboratory  1995
[IBIS ver]   3.2
[File name]   k7x32xxxxc_hstl.ibs
[File Rev]   0.3
[Date]   Monday, April 24, 2006
[Source]   File originated from SAMSUNG Electronics Co.
[Notes]   This IBIS model is for modeling purposes only, and is not
   guaranteed
[Disclaimer] This IBIS model provided as is". SAMSUNG is not responsible
                 for any problems this model may cause to the customers.
                 Customers may only modify the IBIS model to fit their
                 particular applications.
[Copyright]   Copyright 04/2006, SAMSUNG Electronics Co. All rights
   reserved.
|   Component k7k3236t2c_165fbga
[Component]   k7k3236t2c_165fbga
[Manufacturer]   Samsung Electronics Co., LTD.
[Package]
| variable   typ   min(slow/weak)   max(fast/strong)
R_pkg   0.5674   0.3830   0.6400
L_pkg   3.4428nH   1.8500nH   4.5663nH
C_pkg   0.7742pF   0.4699pF   1.2167pF
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
1A   /CQ   HSTL_DQ_SELECTOR   0.5806  3.9389nH   0.6285pF
1B   NC   NC   0.6105  4.1489nH   0.7757pF
1C   NC   NC   0.6173  3.9281nH   0.8396pF
1D   NC   NC   0.6062  3.8334nH   0.7934pF
1E   NC   NC   0.6073  4.5663nH   0.7742pF
1F   NC   NC   0.6279  4.1398nH   0.8332pF
1G   NC   NC   0.6363  4.1897nH   0.8337pF
1H   /DOFF   HSTL_XAIN_SELECTOR   0.5762  4.228nH 0.4783pF
1J   NC   NC   0.5886  3.8586nH   0.6419pF
1K   NC   NC   0.5702  3.9151nH   0.6804pF
1L   NC   NC   0.6186  4.4317nH   0.8289pF
1M   NC   NC   0.6033  3.8143nH   0.8077pF
1N   NC   NC   0.5748  3.7417nH   0.7354pF
1P   NC   NC   0.6082  4.0511nH   0.7122pF
1R   TDO   HSTL_DQ_SELECTOR   0.4825  3.8965nH   0.5399pF
2A   NC   NC
2B   DQ27   HSTL_DQ_SELECTOR   0.5993  4.1039nH   0.9375pF
2C   NC   NC   0.6295  4.2704nH   0.8745pF
2D   DQ29   HSTL_DQ_SELECTOR   0.6137  3.9102nH   0.9004pF
2E   NC   NC   0.5821  3.4549nH   0.8687pF
2F   DQ30   HSTL_DQ_SELECTOR   0.6137  4.3654nH   0.9727pF
2G   DQ31   HSTL_DQ_SELECTOR   0.5889  4.1267nH   1.0948pF
2H   VREF   POWER
2J   NC   NC   0.5921  3.6122nH   0.8571pF
2K   NC   NC   0.6027  4.0792nH   0.7865pF
2L   DQ33   HSTL_DQ_SELECTOR   0.5519  3.3619nH   0.8709pF
2M   NC   NC   0.5642  3.2659nH   0.8409pF
2N   DQ35   HSTL_DQ_SELECTOR   0.6267  3.6606nH   0.896pF
2P   NC   NC   0.6057  4.1513nH   0.8004pF
2R   TCK   HSTL_XAIN_SELECTOR   0.4392  2.9847nH   0.6138pF
3A   SA   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
3B   DQ18   HSTL_DQ_SELECTOR   0.5749  3.1418nH   0.913pF
3C   DQ28   HSTL_DQ_SELECTOR   0.5490  2.7272nH   0.7035pF
3D   DQ19   HSTL_DQ_SELECTOR   0.5200  2.6346nH   0.6954pF
3E   DQ20   HSTL_DQ_SELECTOR   0.5147  2.7406nH   0.7692pF
3F   DQ21   HSTL_DQ_SELECTOR   0.5610  3.0697nH   0.8624pF
3G   DQ22   HSTL_DQ_SELECTOR   0.5453  3.0317nH   0.7978pF
3H   VDDQ   POWER
3J   DQ32   HSTL_DQ_SELECTOR   0.5597  3.0416nH   0.8177pF
3K   DQ23   HSTL_DQ_SELECTOR   0.5322  2.8051nH   0.8685pF
3L   DQ24   HSTL_DQ_SELECTOR   0.5550  2.8918nH   0.8362pF
3M   DQ34   HSTL_DQ_SELECTOR   0.5628  2.8862nH   0.7503pF
3N   DQ25   HSTL_DQ_SELECTOR   0.5346  2.7591nH   0.7796pF
3P   DQ26   HSTL_DQ_SELECTOR   0.5429  2.9451nH   0.6581pF
3R   SA   HSTL_XAIN_SELECTOR   0.4585  2.6321nH   0.6329pF
4A   R//W   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
4B   SA   HSTL_XAIN_SELECTOR   0.4439  2.5571nH   0.6406pF
4C   VSS   GND
4D   VSS   GND
4E   VDDQ   POWER
4F   VDDQ   POWER
4G   VDDQ   POWER
4H   VDDQ   POWER
4J   VDDQ   POWER
4K   VDDQ   POWER
4L   VDDQ   POWER
4M   VSS   GND
4N   VSS   GND
4P   SA   HSTL_XAIN_SELECTOR   0.4706  2.7258nH   0.626pF
4R   SA   HSTL_XAIN_SELECTOR   0.4202  2.1807nH   0.4786pF
5A   /BW2   HSTL_XAIN_SELECTOR   0.5722  3.1583nH   0.8264pF
5B   /BW3   HSTL_XAIN_SELECTOR   0.4721  2.6495nH   0.595pF
5C   SA   HSTL_XAIN_SELECTOR   0.5081  3.5996nH   0.6172pF
5D   VSS   GND
5E   VSS   GND
5F   VDD   POWER
5G   VDD   POWER
5H   VDD   POWER
5J   VDD   POWER
5K   VDD   POWER
5L   VSS   GND
5M   VSS   GND
5N   SA   HSTL_XAIN_SELECTOR   0.5101  3.1602nH   0.7321pF
5P   SA   HSTL_XAIN_SELECTOR   0.4543  2.4472nH   0.7366pF
5R   SA   HSTL_XAIN_SELECTOR   0.4352  2.1952nH   0.6288pF
6A   /K   HSTL_XAIN_SELECTOR   0.4111  2.2131nH   0.4699pF
6B   K   HSTL_XAIN_SELECTOR   0.4106  2.3306nH   0.5319pF
6C   NC   NC
6D   VSS   GND
6E   VSS   GND
6F   VSS   GND
6G   VSS   GND
6H   VSS   GND
6J   VSS   GND
6K   VSS   GND
6L   VSS   GND
6M   VSS   GND
6N   SA   HSTL_XAIN_SELECTOR   0.4886  2.9932nH   0.717pF
6P   C   HSTL_XAIN_SELECTOR   0.3830  2.1313nH   1.035pF
6R   /C   HSTL_XAIN_SELECTOR   0.3863  2.038nH 0.8317pF
7A   /BW1   HSTL_XAIN_SELECTOR   0.3849  1.85nH  0.5503pF
7B   /BW0   HSTL_XAIN_SELECTOR   0.4342  2.4559nH   0.5619pF
7C   SA   HSTL_XAIN_SELECTOR   0.5330  3.7948nH   0.7261pF
7D   VSS   GND
7E   VSS   GND
7F   VDD   POWER
7G   VDD   POWER
7H   VDD   POWER
7J   VDD   POWER
7K   VDD   POWER
7L   VSS   GND
7M   VSS   GND
7N   SA   HSTL_XAIN_SELECTOR   0.4928  3.0542nH   0.722pF
7P   SA   HSTL_XAIN_SELECTOR   0.4730  2.5441nH   0.7142pF
7R   SA   HSTL_XAIN_SELECTOR   0.4260  2.1586nH   0.5587pF
8A   /LD   HSTL_XAIN_SELECTOR   0.3969  1.9968nH   0.5132pF
8B   SA   HSTL_XAIN_SELECTOR   0.4791  2.797nH 0.7324pF
8C   VSS   GND
8D   VSS   GND
8E   VDDQ   POWER
8F   VDDQ   POWER
8G   VDDQ   POWER
8H   VDDQ   POWER
8J   VDDQ   POWER
8K   VDDQ   POWER
8L   VDDQ   POWER
8M   VSS   GND
8N   VSS   GND
8P   SA   HSTL_XAIN_SELECTOR   0.4642  2.8061nH   0.6481pF
8R   SA   HSTL_XAIN_SELECTOR   0.4125  2.1537nH   0.4825pF
9A   SA   HSTL_XAIN_SELECTOR   0.4409  2.3652nH   0.5243pF
9B   NC   NC   0.5642  2.9663nH   0.6443pF
9C   NC   NC   0.5509  2.7736nH   0.6827pF
9D   NC   NC   0.5301  2.8631nH   0.7376pF
9E   NC   NC   0.5300  2.7685nH   0.8166pF
9F   NC   NC   0.5679  3.1268nH   0.8597pF
9G   NC   NC   0.5329  2.9061nH   0.7653pF
9H   VDDQ   POWER
9J   NC   NC   0.5798  3.3359nH   0.9106pF
9K   NC   NC   0.5115  2.5442nH   0.7088pF
9L   NC   NC   0.5681  2.9096nH   0.7894pF
9M   NC   NC   0.5800  3.0772nH   0.8416pF
9N   NC   NC   0.5380  2.9287nH   0.904pF
9P   NC   NC   0.5433  2.8791nH   0.7152pF
9R   SA   HSTL_XAIN_SELECTOR   0.4425  2.4764nH   0.6482pF
10A   VSS   GND
10B   NC   NC   0.5878  3.7249nH   0.7409pF
10C   DQ17   HSTL_DQ_SELECTOR   0.6343  4.4216nH   0.8991pF
10D   NC   NC   0.6051  4.0228nH   0.8841pF
10E   DQ15   HSTL_DQ_SELECTOR   0.6204  4.0638nH   1.0204pF
10F   NC   NC   0.5698  3.4524nH   0.7654pF
10G   NC   NC   0.6141  3.779nH 0.8566pF
10H   VREF   POWER
10J   DQ13   HSTL_DQ_SELECTOR   0.5859  3.4567nH   1.2167pF
10K   DQ12   HSTL_DQ_SELECTOR   0.5910  3.7557nH   0.9646pF
10L   NC   NC   0.6097  4.0851nH   0.823pF
10M   DQ11   HSTL_DQ_SELECTOR   0.5694  3.477nH 0.8106pF
10N   NC   HSTL_DQ_SELECTOR   0.5882  3.4428nH   0.8062pF
10P   DQ9   HSTL_DQ_SELECTOR   0.5759  3.5776nH   0.8543pF
10R   TMS   HSTL_XAIN_SELECTOR   0.4318  2.7023nH   0.6422pF
11A   CQ   HSTL_DQ_SELECTOR   0.5643  3.859nH 0.5208pF
11B   DQ8   HSTL_DQ_SELECTOR   0.5674  3.8866nH   0.6813pF
11C   DQ7   HSTL_DQ_SELECTOR   0.6395  4.1994nH   0.8543pF
11D   DQ16   HSTL_DQ_SELECTOR   0.5867  3.8011nH   0.7967pF
11E   DQ6   HSTL_DQ_SELECTOR   0.6400  4.1203nH   0.8725pF
11F   DQ5   HSTL_DQ_SELECTOR   0.5950  4.389nH 0.7934pF
11G   DQ14   HSTL_DQ_SELECTOR   0.6323  4.3389nH   0.8472pF
11H   ZQ   HSTL_XAIN_SELECTOR   0.6099  4.4619nH   0.4781pF
11J   DQ4   HSTL_DQ_SELECTOR   0.5882  3.9082nH   0.6089pF
11K   DQ3   HSTL_DQ_SELECTOR   0.6030  4.1177nH   0.8414pF
11L   DQ2   HSTL_DQ_SELECTOR   0.5818  3.9752nH   0.7472pF
11M   DQ1   HSTL_DQ_SELECTOR   0.5712  3.6156nH   0.8142pF
11N   DQ10   HSTL_DQ_SELECTOR   0.6075  3.9131nH   0.8497pF
11P   DQ0   HSTL_DQ_SELECTOR   0.5948  4.1522nH   1.1364pF
11R   TDI   HSTL_XAIN_SELECTOR   0.4759  3.5856nH   0.565pF
|   Component k7k3218t2c_165fbga
[Component]   k7k3218t2c_165fbga
[Manufacturer]   Samsung Electronics Co., LTD.
[Package]
| variable   typ   min(slow/weak)   max(fast/strong)
R_pkg   0.5674   0.3830   0.6400
L_pkg   3.4428nH   1.8500nH   4.5663nH
C_pkg   0.7742pF   0.4699pF   1.2167pF
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
1A   /CQ   HSTL_DQ_SELECTOR   0.5806  3.9389nH   0.6285pF
1B   NC   NC   0.6105  4.1489nH   0.7757pF
1C   NC   NC   0.6173  3.9281nH   0.8396pF
1D   NC   NC   0.6062  3.8334nH   0.7934pF
1E   NC   NC   0.6073  4.5663nH   0.7742pF
1F   NC   NC   0.6279  4.1398nH   0.8332pF
1G   NC   NC   0.6363  4.1897nH   0.8337pF
1H   /DOFF   HSTL_XAIN_SELECTOR   0.5762  4.228nH 0.4783pF
1J   NC   NC   0.5886  3.8586nH   0.6419pF
1K   NC   NC   0.5702  3.9151nH   0.6804pF
1L   NC   NC   0.6186  4.4317nH   0.8289pF
1M   NC   NC   0.6033  3.8143nH   0.8077pF
1N   NC   NC   0.5748  3.7417nH   0.7354pF
1P   NC   NC   0.6082  4.0511nH   0.7122pF
1R   TDO   HSTL_DQ_SELECTOR   0.4825  3.8965nH   0.5399pF
2A   VSS   GND
2B   DQ9   HSTL_DQ_SELECTOR   0.5993  4.1039nH   0.9375pF
2C   NC   NC   0.6295  4.2704nH   0.8745pF
2D   NC   NC   0.6137  3.9102nH   0.9004pF
2E   NC   NC   0.5821  3.4549nH   0.8687pF
2F   DQ12   HSTL_DQ_SELECTOR   0.6137  4.3654nH   0.9727pF
2G   NC   NC   0.5889  4.1267nH   1.0948pF
2H   VREF   POWER
2J   NC   NC   0.5921  3.6122nH   0.8571pF
2K   NC   NC   0.6027  4.0792nH   0.7865pF
2L   DQ15   HSTL_DQ_SELECTOR   0.5519  3.3619nH   0.8709pF
2M   NC   NC   0.5642  3.2659nH   0.8409pF
2N   NC   NC   0.6267  3.6606nH   0.896pF
2P   NC   NC   0.6057  4.1513nH   0.8004pF
2R   TCK   HSTL_XAIN_SELECTOR   0.4392  2.9847nH   0.6138pF
3A   A19   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
3B   NC   NC   0.5749  3.1418nH   0.913pF
3C   NC   NC   0.5490  2.7272nH   0.7035pF
3D   DQ10   HSTL_DQ_SELECTOR   0.5200  2.6346nH   0.6954pF
3E   DQ11   HSTL_DQ_SELECTOR   0.5147  2.7406nH   0.7692pF
3F   NC   NC   0.5610  3.0697nH   0.8624pF
3G   DQ13   HSTL_DQ_SELECTOR   0.5453  3.0317nH   0.7978pF
3H   VDDQ   POWER
3J   NC   NC   0.5597  3.0416nH   0.8177pF
3K   DQ14   HSTL_DQ_SELECTOR   0.5322  2.8051nH   0.8685pF
3L   NC   NC   0.5550  2.8918nH   0.8362pF
3M   NC   NC   0.5628  2.8862nH   0.7503pF
3N   DQ16   HSTL_DQ_SELECTOR   0.5346  2.7591nH   0.7796pF
3P   DQ17   HSTL_DQ_SELECTOR   0.5429  2.9451nH   0.6581pF
3R   A7   HSTL_XAIN_SELECTOR   0.4585  2.6321nH   0.6329pF
4A   R//W   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
4B   A18   HSTL_XAIN_SELECTOR   0.4439  2.5571nH   0.6406pF
4C   VSS   GND
4D   VSS   GND
4E   VDDQ   POWER
4F   VDDQ   POWER
4G   VDDQ   POWER
4H   VDDQ   POWER
4J   VDDQ   POWER
4K   VDDQ   POWER
4L   VDDQ   POWER
4M   VSS   GND
4N   VSS   GND
4P   A5   HSTL_XAIN_SELECTOR   0.4706  2.7258nH   0.626pF
4R   A6   HSTL_XAIN_SELECTOR   0.4202  2.1807nH   0.4786pF
5A   /BW1   HSTL_XAIN_SELECTOR   0.5722  3.1583nH   0.8264pF
5B   NC   NC   0.4721  2.6495nH   0.595pF
5C   A17   HSTL_XAIN_SELECTOR   0.5081  3.5996nH   0.6172pF
5D   VSS   GND
5E   VSS   GND
5F   VDD   POWER
5G   VDD   POWER
5H   VDD   POWER
5J   VDD   POWER
5K   VDD   POWER
5L   VSS   GND
5M   VSS   GND
5N   A3   HSTL_XAIN_SELECTOR   0.5101  3.1602nH   0.7321pF
5P   A4   HSTL_XAIN_SELECTOR   0.4543  2.4472nH   0.7366pF
5R   A2   HSTL_XAIN_SELECTOR   0.4352  2.1952nH   0.6288pF
6A   /K   HSTL_XAIN_SELECTOR   0.4111  2.2131nH   0.4699pF
6B   K   HSTL_XAIN_SELECTOR   0.4106  2.3306nH   0.5319pF
6C   NC   NC
6D   VSS   GND
6E   VSS   GND
6F   VSS   GND
6G   VSS   GND
6H   VSS   GND
6J   VSS   GND
6K   VSS   GND
6L   VSS   GND
6M   VSS   GND
6N   A8   HSTL_XAIN_SELECTOR   0.4886  2.9932nH   0.717pF
6P   C   HSTL_XAIN_SELECTOR   0.3830  2.1313nH   1.035pF
6R   /C   HSTL_XAIN_SELECTOR   0.3863  2.038nH 0.8317pF
7A   NC   NC   0.3849  1.85nH  0.5503pF
7B   /BW0   HSTL_XAIN_SELECTOR   0.4342  2.4559nH   0.5619pF
7C   A1   HSTL_XAIN_SELECTOR   0.5330  3.7948nH   0.7261pF
7D   VSS   GND
7E   VSS   GND
7F   VDD   POWER
7G   VDD   POWER
7H   VDD   POWER
7J   VDD   POWER
7K   VDD   POWER
7L   VSS   GND
7M   VSS   GND
7N   A10   HSTL_XAIN_SELECTOR   0.4928  3.0542nH   0.722pF
7P   A9   HSTL_XAIN_SELECTOR   0.4730  2.5441nH   0.7142pF
7R   A11   HSTL_XAIN_SELECTOR   0.4260  2.1586nH   0.5587pF
8A   /LD   HSTL_XAIN_SELECTOR   0.3969  1.9968nH   0.5132pF
8B   A16   HSTL_XAIN_SELECTOR   0.4791  2.797nH 0.7324pF
8C   VSS   GND
8D   VSS   GND
8E   VDDQ   POWER
8F   VDDQ   POWER
8G   VDDQ   POWER
8H   VDDQ   POWER
8J   VDDQ   POWER
8K   VDDQ   POWER
8L   VDDQ   POWER
8M   VSS   GND
8N   VSS   GND
8P   A13   HSTL_XAIN_SELECTOR   0.4642  2.8061nH   0.6481pF
8R   A12   HSTL_XAIN_SELECTOR   0.4125  2.1537nH   0.4825pF
9A   A15   HSTL_XAIN_SELECTOR   0.4409  2.3652nH   0.5243pF
9B   NC   NC   0.5642  2.9663nH   0.6443pF
9C   NC   NC   0.5509  2.7736nH   0.6827pF
9D   NC   NC   0.5301  2.8631nH   0.7376pF
9E   NC   NC   0.5300  2.7685nH   0.8166pF
9F   NC   NC   0.5679  3.1268nH   0.8597pF
9G   NC   NC   0.5329  2.9061nH   0.7653pF
9H   VDDQ   POWER
9J   NC   NC   0.5798  3.3359nH   0.9106pF
9K   NC   NC   0.5115  2.5442nH   0.7088pF
9L   NC   NC   0.5681  2.9096nH   0.7894pF
9M   NC   NC   0.5800  3.0772nH   0.8416pF
9N   NC   NC   0.5380  2.9287nH   0.904pF
9P   NC   NC   0.5433  2.8791nH   0.7152pF
9R   A14   HSTL_XAIN_SELECTOR   0.4425  2.4764nH   0.6482pF
10A   SA20   HSTL_XAIN_SELECTOR   0.5643  3.859nH 0.5208pF
10B   NC   NC   0.5878  3.7249nH   0.7409pF
10C   DQ7   HSTL_DQ_SELECTOR   0.6343  4.4216nH   0.8991pF
10D   NC   NC   0.6051  4.0228nH   0.8841pF
10E   NC   NC   0.6204  4.0638nH   1.0204pF
10F   NC   NC   0.5698  3.4524nH   0.7654pF
10G   NC   NC   0.6141  3.779nH 0.8566pF
10H   VREF   POWER
10J   DQ4   HSTL_DQ_SELECTOR   0.5859  3.4567nH   1.2167pF
10K   NC   HSTL_DQ_SELECTOR   0.5910  3.7557nH   0.9646pF
10L   NC   NC   0.6097  4.0851nH   0.823pF
10M   DQ1   HSTL_DQ_SELECTOR   0.5694  3.477nH 0.8106pF
10N   NC   HSTL_DQ_SELECTOR   0.5882  3.4428nH   0.8062pF
10P   NC   NC   0.5759  3.5776nH   0.8543pF
10R   TMS   HSTL_XAIN_SELECTOR   0.4318  2.7023nH   0.6422pF
11A   CQ   HSTL_DQ_SELECTOR   0.5643  3.859nH 0.5208pF
11B   DQ8   HSTL_DQ_SELECTOR   0.5674  3.8866nH   0.6813pF
11C   NC   NC   0.6395  4.1994nH   0.8543pF
11D   NC   NC   0.5867  3.8011nH   0.7967pF
11E   DQ6   HSTL_DQ_SELECTOR   0.6400  4.1203nH   0.8725pF
11F   DQ5   HSTL_DQ_SELECTOR   0.5950  4.389nH 0.7934pF
11G   NC   NC   0.6323  4.3389nH   0.8472pF
11H   ZQ   HSTL_XAIN_SELECTOR   0.6099  4.4619nH   0.4781pF
11J   NC   NC   0.5882  3.9082nH   0.6089pF
11K   DQ3   HSTL_DQ_SELECTOR   0.6030  4.1177nH   0.8414pF
11L   DQ2   HSTL_DQ_SELECTOR   0.5818  3.9752nH   0.7472pF
11M   NC   NC   0.5712  3.6156nH   0.8142pF
11N   NC   NC   0.6075  3.9131nH   0.8497pF
11P   DQ0   HSTL_DQ_SELECTOR   0.5948  4.1522nH   1.1364pF
11R   TDI   HSTL_XAIN_SELECTOR   0.4759  3.5856nH   0.565pF
|   Component k7s3236t4c_165fbga
[Component]   k7s3236t4c_165fbga
[Manufacturer]   Samsung Electronics Co., LTD.
[Package]
| variable   typ   min(slow/weak)   max(fast/strong)
R_pkg   0.5674   0.3830   0.6400
L_pkg   3.4428nH   1.8500nH   4.5663nH
C_pkg   0.7742pF   0.4699pF   1.2167pF
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
1A   /CQ   HSTL_OUT_SELECTOR   0.5806  3.9389nH   0.6285pF
1B   Q27   HSTL_OUT_SELECTOR   0.6105  4.1489nH   0.7757pF
1C   D27   HSTL_DIN_SELECTOR   0.6173  3.9281nH   0.8396pF
1D   D28   HSTL_DIN_SELECTOR   0.6062  3.8334nH   0.7934pF
1E   Q29   HSTL_OUT_SELECTOR   0.6073  4.5663nH   0.7742pF
1F   Q30   HSTL_OUT_SELECTOR   0.6279  4.1398nH   0.8332pF
1G   D30   HSTL_DIN_SELECTOR   0.6363  4.1897nH   0.8337pF
1H   /DOFF   HSTL_XAIN_SELECTOR   0.5762  4.228nH 0.4783pF
1J   D31   HSTL_DIN_SELECTOR   0.5886  3.8586nH   0.6419pF
1K   Q32   HSTL_OUT_SELECTOR   0.5702  3.9151nH   0.6804pF
1L   Q33   HSTL_OUT_SELECTOR   0.6186  4.4317nH   0.8289pF
1M   D33   HSTL_DIN_SELECTOR   0.6033  3.8143nH   0.8077pF
1N   D34   HSTL_DIN_SELECTOR   0.5748  3.7417nH   0.7354pF
1P   Q35   HSTL_OUT_SELECTOR   0.6082  4.0511nH   0.7122pF
1R   TDO   HSTL_OUT_SELECTOR   0.4825  3.8965nH   0.5399pF
2A   NC   NC
2B   Q18   HSTL_OUT_SELECTOR   0.5993  4.1039nH   0.9375pF
2C   Q28   HSTL_OUT_SELECTOR   0.6295  4.2704nH   0.8745pF
2D   D20   HSTL_DIN_SELECTOR   0.6137  3.9102nH   0.9004pF
2E   D29   HSTL_DIN_SELECTOR   0.5821  3.4549nH   0.8687pF
2F   Q21   HSTL_OUT_SELECTOR   0.6137  4.3654nH   0.9727pF
2G   D22   HSTL_DIN_SELECTOR   0.5889  4.1267nH   1.0948pF
2H   VREF   POWER
2J   Q31   HSTL_OUT_SELECTOR   0.5921  3.6122nH   0.8571pF
2K   D32   HSTL_DIN_SELECTOR   0.6027  4.0792nH   0.7865pF
2L   Q24   HSTL_OUT_SELECTOR   0.5519  3.3619nH   0.8709pF
2M   Q34   HSTL_OUT_SELECTOR   0.5642  3.2659nH   0.8409pF
2N   D26   HSTL_DIN_SELECTOR   0.6267  3.6606nH   0.896pF
2P   D35   HSTL_DIN_SELECTOR   0.6057  4.1513nH   0.8004pF
2R   TCK   HSTL_XAIN_SELECTOR   0.4392  2.9847nH   0.6138pF
3A   NC   NC
3B   D18   HSTL_DIN_SELECTOR   0.5749  3.1418nH   0.913pF
3C   D19   HSTL_DIN_SELECTOR   0.5490  2.7272nH   0.7035pF
3D   Q19   HSTL_OUT_SELECTOR   0.5200  2.6346nH   0.6954pF
3E   Q20   HSTL_OUT_SELECTOR   0.5147  2.7406nH   0.7692pF
3F   D21   HSTL_DIN_SELECTOR   0.5610  3.0697nH   0.8624pF
3G   Q22   HSTL_OUT_SELECTOR   0.5453  3.0317nH   0.7978pF
3H   VDDQ   POWER
3J   D23   HSTL_DIN_SELECTOR   0.5597  3.0416nH   0.8177pF
3K   Q23   HSTL_OUT_SELECTOR   0.5322  2.8051nH   0.8685pF
3L   D24   HSTL_DIN_SELECTOR   0.5550  2.8918nH   0.8362pF
3M   D25   HSTL_DIN_SELECTOR   0.5628  2.8862nH   0.7503pF
3N   Q25   HSTL_OUT_SELECTOR   0.5346  2.7591nH   0.7796pF
3P   Q26   HSTL_OUT_SELECTOR   0.5429  2.9451nH   0.6581pF
3R   SA   HSTL_XAIN_SELECTOR   0.4585  2.6321nH   0.6329pF
4A   /W   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
4B   SA   HSTL_XAIN_SELECTOR   0.4439  2.5571nH   0.6406pF
4C   VSS   GND
4D   VSS   GND
4E   VDDQ   POWER
4F   VDDQ   POWER
4G   VDDQ   POWER
4H   VDDQ   POWER
4J   VDDQ   POWER
4K   VDDQ   POWER
4L   VDDQ   POWER
4M   VSS   GND
4N   VSS   GND
4P   SA   HSTL_XAIN_SELECTOR   0.4706  2.7258nH   0.626pF
4R   SA   HSTL_XAIN_SELECTOR   0.4202  2.1807nH   0.4786pF
5A   /BW2   HSTL_XAIN_SELECTOR   0.5722  3.1583nH   0.8264pF
5B   /BW3   HSTL_XAIN_SELECTOR   0.4721  2.6495nH   0.595pF
5C   SA   HSTL_XAIN_SELECTOR   0.5081  3.5996nH   0.6172pF
5D   VSS   GND
5E   VSS   GND
5F   VDD   POWER
5G   VDD   POWER
5H   VDD   POWER
5J   VDD   POWER
5K   VDD   POWER
5L   VSS   GND
5M   VSS   GND
5N   SA   HSTL_XAIN_SELECTOR   0.5101  3.1602nH   0.7321pF
5P   SA   HSTL_XAIN_SELECTOR   0.4543  2.4472nH   0.7366pF
5R   SA   HSTL_XAIN_SELECTOR   0.4352  2.1952nH   0.6288pF
6A   /K   HSTL_XAIN_SELECTOR   0.4111  2.2131nH   0.4699pF
6B   K   HSTL_XAIN_SELECTOR   0.4106  2.3306nH   0.5319pF
6C   NC   NC
6D   VSS   GND
6E   VSS   GND
6F   VSS   GND
6G   VSS   GND
6H   VSS   GND
6J   VSS   GND
6K   VSS   GND
6L   VSS   GND
6M   VSS   GND
6N   SA   HSTL_XAIN_SELECTOR   0.4886  2.9932nH   0.717pF
6P   QVLD   HSTL_XAIN_SELECTOR   0.3830  2.1313nH   1.035pF
6R   NC   NC
7A   /BW1   HSTL_XAIN_SELECTOR   0.3849  1.85nH  0.5503pF
7B   /BW0   HSTL_XAIN_SELECTOR   0.4342  2.4559nH   0.5619pF
7C   SA   HSTL_XAIN_SELECTOR   0.5330  3.7948nH   0.7261pF
7D   VSS   GND
7E   VSS   GND
7F   VDD   POWER
7G   VDD   POWER
7H   VDD   POWER
7J   VDD   POWER
7K   VDD   POWER
7L   VSS   GND
7M   VSS   GND
7N   SA   HSTL_XAIN_SELECTOR   0.4928  3.0542nH   0.722pF
7P   SA   HSTL_XAIN_SELECTOR   0.4730  2.5441nH   0.7142pF
7R   SA   HSTL_XAIN_SELECTOR   0.4260  2.1586nH   0.5587pF
8A   /R   HSTL_XAIN_SELECTOR   0.3969  1.9968nH   0.5132pF
8B   SA   HSTL_XAIN_SELECTOR   0.4791  2.797nH 0.7324pF
8C   VSS   GND
8D   VSS   GND
8E   VDDQ   POWER
8F   VDDQ   POWER
8G   VDDQ   POWER
8H   VDDQ   POWER
8J   VDDQ   POWER
8K   VDDQ   POWER
8L   VDDQ   POWER
8M   VSS   GND
8N   VSS   GND
8P   SA   HSTL_XAIN_SELECTOR   0.4642  2.8061nH   0.6481pF
8R   SA   HSTL_XAIN_SELECTOR   0.4125  2.1537nH   0.4825pF
9A   SA   HSTL_XAIN_SELECTOR   0.4409  2.3652nH   0.5243pF
9B   D17   HSTL_DIN_SELECTOR   0.5642  2.9663nH   0.6443pF
9C   D16   HSTL_DIN_SELECTOR   0.5509  2.7736nH   0.6827pF
9D   Q16   HSTL_OUT_SELECTOR   0.5301  2.8631nH   0.7376pF
9E   Q15   HSTL_OUT_SELECTOR   0.5300  2.7685nH   0.8166pF
9F   D14   HSTL_DIN_SELECTOR   0.5679  3.1268nH   0.8597pF
9G   Q13   HSTL_OUT_SELECTOR   0.5329  2.9061nH   0.7653pF
9H   VDDQ   POWER
9J   D12   HSTL_DIN_SELECTOR   0.5798  3.3359nH   0.9106pF
9K   Q12   HSTL_OUT_SELECTOR   0.5115  2.5442nH   0.7088pF
9L   D11   HSTL_DIN_SELECTOR   0.5681  2.9096nH   0.7894pF
9M   D10   HSTL_DIN_SELECTOR   0.5800  3.0772nH   0.8416pF
9N   Q10   HSTL_OUT_SELECTOR   0.5380  2.9287nH   0.904pF
9P   Q9   HSTL_OUT_SELECTOR   0.5433  2.8791nH   0.7152pF
9R   SA   HSTL_XAIN_SELECTOR   0.4425  2.4764nH   0.6482pF
10A   NC   NC
10B   Q17   HSTL_OUT_SELECTOR   0.5878  3.7249nH   0.7409pF
10C   Q7   HSTL_OUT_SELECTOR   0.6343  4.4216nH   0.8991pF
10D   D15   HSTL_DIN_SELECTOR   0.6051  4.0228nH   0.8841pF
10E   D6   HSTL_DIN_SELECTOR   0.6204  4.0638nH   1.0204pF
10F   Q14   HSTL_OUT_SELECTOR   0.5698  3.4524nH   0.7654pF
10G   D13   HSTL_DIN_SELECTOR   0.6141  3.779nH 0.8566pF
10H   VREF   POWER
10J   Q4   HSTL_OUT_SELECTOR   0.5859  3.4567nH   1.2167pF
10K   D3   HSTL_DIN_SELECTOR   0.5910  3.7557nH   0.9646pF
10L   Q11   HSTL_OUT_SELECTOR   0.6097  4.0851nH   0.823pF
10M   Q1   HSTL_OUT_SELECTOR   0.5694  3.477nH 0.8106pF
10N   D9   HSTL_DIN_SELECTOR   0.5882  3.4428nH   0.8062pF
10P   D0   HSTL_DIN_SELECTOR   0.5759  3.5776nH   0.8543pF
10R   TMS   HSTL_XAIN_SELECTOR   0.4318  2.7023nH   0.6422pF
11A   CQ   HSTL_OUT_SELECTOR   0.5643  3.859nH 0.5208pF
11B   Q8   HSTL_OUT_SELECTOR   0.5674  3.8866nH   0.6813pF
11C   D8   HSTL_DIN_SELECTOR   0.6395  4.1994nH   0.8543pF
11D   D7   HSTL_DIN_SELECTOR   0.5867  3.8011nH   0.7967pF
11E   Q6   HSTL_OUT_SELECTOR   0.6400  4.1203nH   0.8725pF
11F   Q5   HSTL_OUT_SELECTOR   0.5950  4.389nH 0.7934pF
11G   D5   HSTL_DIN_SELECTOR   0.6323  4.3389nH   0.8472pF
11H   ZQ   HSTL_XAIN_SELECTOR   0.6099  4.4619nH   0.4781pF
11J   D4   HSTL_DIN_SELECTOR   0.5882  3.9082nH   0.6089pF
11K   Q3   HSTL_OUT_SELECTOR   0.6030  4.1177nH   0.8414pF
11L   Q2   HSTL_OUT_SELECTOR   0.5818  3.9752nH   0.7472pF
11M   D2   HSTL_DIN_SELECTOR   0.5712  3.6156nH   0.8142pF
11N   D1   HSTL_DIN_SELECTOR   0.6075  3.9131nH   0.8497pF
11P   Q0   HSTL_OUT_SELECTOR   0.5948  4.1522nH   1.1364pF
11R   TDI   HSTL_XAIN_SELECTOR   0.4759  3.5856nH   0.565pF
|   Component k7s3218t4c_165fbga
[Component]   k7s3218t4c_165fbga
[Manufacturer]   Samsung Electronics Co., LTD.
[Package]
| variable   typ   min(slow/weak)   max(fast/strong)
R_pkg   0.5674   0.3830   0.6400
L_pkg   3.4428nH   1.8500nH   4.5663nH
C_pkg   0.7742pF   0.4699pF   1.2167pF
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
1A   /CQ   HSTL_OUT_SELECTOR   0.5806  3.9389nH   0.6285pF
1B   NC   NC
1C   NC   NC
1D   NC   NC
1E   NC   NC
1F   NC   NC
1G   NC   NC
1H   /DOFF   HSTL_XAIN_SELECTOR   0.5762  4.228nH 0.4783pF
1J   NC   NC
1K   NC   NC
1L   NC   NC
1M   NC   NC
1N   NC   NC
1P   NC   NC
1R   TDO   HSTL_OUT_SELECTOR   0.4825  3.8965nH   0.5399pF
2A   NC   NC
2B   Q9   HSTL_OUT_SELECTOR   0.5993  4.1039nH   0.9375pF
2C   NC   HSTL_OUT_SELECTOR
2D   D11   HSTL_DIN_SELECTOR   0.6137  3.9102nH   0.9004pF
2E   NC   HSTL_DIN_SELECTOR
2F   Q12   HSTL_OUT_SELECTOR   0.6137  4.3654nH   0.9727pF
2G   D13   HSTL_DIN_SELECTOR   0.5889  4.1267nH   1.0948pF
2H   VREF   POWER
2J   NC   NC
2K   NC   NC
2L   Q15   HSTL_OUT_SELECTOR   0.5519  3.3619nH   0.8709pF
2M   NC   HSTL_OUT_SELECTOR
2N   D17   HSTL_DIN_SELECTOR   0.6267  3.6606nH   0.896pF
2P   NC   HSTL_DIN_SELECTOR
2R   TCK   HSTL_XAIN_SELECTOR   0.4392  2.9847nH   0.6138pF
3A   SA   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
3B   D9   HSTL_DIN_SELECTOR   0.5749  3.1418nH   0.913pF
3C   D10   HSTL_DIN_SELECTOR   0.5490  2.7272nH   0.7035pF
3D   Q10   HSTL_OUT_SELECTOR   0.5200  2.6346nH   0.6954pF
3E   Q11   HSTL_OUT_SELECTOR   0.5147  2.7406nH   0.7692pF
3F   D12   HSTL_DIN_SELECTOR   0.5610  3.0697nH   0.8624pF
3G   Q13   HSTL_OUT_SELECTOR   0.5453  3.0317nH   0.7978pF
3H   VDDQ   POWER
3J   D14   HSTL_DIN_SELECTOR   0.5597  3.0416nH   0.8177pF
3K   Q14   HSTL_OUT_SELECTOR   0.5322  2.8051nH   0.8685pF
3L   D15   HSTL_DIN_SELECTOR   0.5550  2.8918nH   0.8362pF
3M   D16   HSTL_DIN_SELECTOR   0.5628  2.8862nH   0.7503pF
3N   Q16   HSTL_OUT_SELECTOR   0.5346  2.7591nH   0.7796pF
3P   Q17   HSTL_OUT_SELECTOR   0.5429  2.9451nH   0.6581pF
3R   SA   HSTL_XAIN_SELECTOR   0.4585  2.6321nH   0.6329pF
4A   /W   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
4B   SA   HSTL_XAIN_SELECTOR   0.4439  2.5571nH   0.6406pF
4C   VSS   GND
4D   VSS   GND
4E   VDDQ   POWER
4F   VDDQ   POWER
4G   VDDQ   POWER
4H   VDDQ   POWER
4J   VDDQ   POWER
4K   VDDQ   POWER
4L   VDDQ   POWER
4M   VSS   GND
4N   VSS   GND
4P   SA   HSTL_XAIN_SELECTOR   0.4706  2.7258nH   0.626pF
4R   SA   HSTL_XAIN_SELECTOR   0.4202  2.1807nH   0.4786pF
5A   /BW1   HSTL_XAIN_SELECTOR   0.5722  3.1583nH   0.8264pF
5B   NC   NC
5C   SA   HSTL_XAIN_SELECTOR   0.5081  3.5996nH   0.6172pF
5D   VSS   GND
5E   VSS   GND
5F   VDD   POWER
5G   VDD   POWER
5H   VDD   POWER
5J   VDD   POWER
5K   VDD   POWER
5L   VSS   GND
5M   VSS   GND
5N   SA   HSTL_XAIN_SELECTOR   0.5101  3.1602nH   0.7321pF
5P   SA   HSTL_XAIN_SELECTOR   0.4543  2.4472nH   0.7366pF
5R   SA   HSTL_XAIN_SELECTOR   0.4352  2.1952nH   0.6288pF
6A   /K   HSTL_XAIN_SELECTOR   0.4111  2.2131nH   0.4699pF
6B   K   HSTL_XAIN_SELECTOR   0.4106  2.3306nH   0.5319pF
6C   NC   NC
6D   VSS   GND
6E   VSS   GND
6F   VSS   GND
6G   VSS   GND
6H   VSS   GND
6J   VSS   GND
6K   VSS   GND
6L   VSS   GND
6M   VSS   GND
6N   SA   HSTL_XAIN_SELECTOR   0.4886  2.9932nH   0.717pF
6P   QVLD   HSTL_XAIN_SELECTOR   0.3830  2.1313nH   1.035pF
6R   NC   NC
7A   NC   NC
7B   /BW0   HSTL_XAIN_SELECTOR   0.4342  2.4559nH   0.5619pF
7C   SA   HSTL_XAIN_SELECTOR   0.5330  3.7948nH   0.7261pF
7D   VSS   GND
7E   VSS   GND
7F   VDD   POWER
7G   VDD   POWER
7H   VDD   POWER
7J   VDD   POWER
7K   VDD   POWER
7L   VSS   GND
7M   VSS   GND
7N   SA   HSTL_XAIN_SELECTOR   0.4928  3.0542nH   0.722pF
7P   SA   HSTL_XAIN_SELECTOR   0.4730  2.5441nH   0.7142pF
7R   SA   HSTL_XAIN_SELECTOR   0.4260  2.1586nH   0.5587pF
8A   /R   HSTL_XAIN_SELECTOR   0.3969  1.9968nH   0.5132pF
8B   SA   HSTL_XAIN_SELECTOR   0.4791  2.797nH 0.7324pF
8C   VSS   GND
8D   VSS   GND
8E   VDDQ   POWER
8F   VDDQ   POWER
8G   VDDQ   POWER
8H   VDDQ   POWER
8J   VDDQ   POWER
8K   VDDQ   POWER
8L   VDDQ   POWER
8M   VSS   GND
8N   VSS   GND
8P   SA   HSTL_XAIN_SELECTOR   0.4642  2.8061nH   0.6481pF
8R   SA   HSTL_XAIN_SELECTOR   0.4125  2.1537nH   0.4825pF
9A   SA   HSTL_XAIN_SELECTOR   0.4409  2.3652nH   0.5243pF
9B   NC   NC
9C   NC   NC
9D   NC   NC
9E   NC   NC
9F   NC   NC
9G   NC   NC
9H   VDDQ   POWER
9J   NC   NC
9K   NC   NC
9L   NC   NC
9M   NC   NC
9N   NC   NC
9P   NC   NC
9R   SA   HSTL_XAIN_SELECTOR   0.4425  2.4764nH   0.6482pF
10A   NC   NC
10B   NC   NC
10C   Q7   HSTL_OUT_SELECTOR   0.6343  4.4216nH   0.8991pF
10D   NC   NC
10E   D6   HSTL_DIN_SELECTOR   0.6204  4.0638nH   1.0204pF
10F   NC   NC
10G   NC   NC
10H   VREF   POWER
10J   Q4   HSTL_OUT_SELECTOR   0.5859  3.4567nH   1.2167pF
10K   D3   HSTL_DIN_SELECTOR   0.5910  3.7557nH   0.9646pF
10L   NC   NC
10M   Q1   HSTL_OUT_SELECTOR   0.5694  3.477nH 0.8106pF
10N   NC   NC
10P   D0   HSTL_DIN_SELECTOR   0.5759  3.5776nH   0.8543pF
10R   TMS   HSTL_XAIN_SELECTOR   0.4318  2.7023nH   0.6422pF
11A   CQ   HSTL_OUT_SELECTOR   0.5643  3.859nH 0.5208pF
11B   Q8   HSTL_OUT_SELECTOR   0.5674  3.8866nH   0.6813pF
11C   D8   HSTL_DIN_SELECTOR   0.6395  4.1994nH   0.8543pF
11D   D7   HSTL_DIN_SELECTOR   0.5867  3.8011nH   0.7967pF
11E   Q6   HSTL_OUT_SELECTOR   0.6400  4.1203nH   0.8725pF
11F   Q5   HSTL_OUT_SELECTOR   0.5950  4.389nH 0.7934pF
11G   D5   HSTL_DIN_SELECTOR   0.6323  4.3389nH   0.8472pF
11H   ZQ   HSTL_XAIN_SELECTOR   0.6099  4.4619nH   0.4781pF
11J   D4   HSTL_DIN_SELECTOR   0.5882  3.9082nH   0.6089pF
11K   Q3   HSTL_OUT_SELECTOR   0.6030  4.1177nH   0.8414pF
11L   Q2   HSTL_OUT_SELECTOR   0.5818  3.9752nH   0.7472pF
11M   D2   HSTL_DIN_SELECTOR   0.5712  3.6156nH   0.8142pF
11N   D1   HSTL_DIN_SELECTOR   0.6075  3.9131nH   0.8497pF
11P   Q0   HSTL_OUT_SELECTOR   0.5948  4.1522nH   1.1364pF
11R   TDI   HSTL_XAIN_SELECTOR   0.4759  3.5856nH   0.565pF
|   Component k7i323684c_165fbga
[Component]   k7i323684c_165fbga
[Manufacturer]   Samsung Electronics Co., LTD.
[Package]
| variable   typ   min(slow/weak)   max(fast/strong)
R_pkg   0.5674   0.3830   0.6400
L_pkg   3.4428nH   1.8500nH   4.5663nH
C_pkg   0.7742pF   0.4699pF   1.2167pF
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
1A   /CQ   HSTL_DQ_SELECTOR   0.5806  3.9389nH   0.6285pF
1B   NC   NC
1C   NC   NC
1D   NC   NC
1E   NC   NC
1F   NC   NC
1G   NC   NC
1H   /DOFF   HSTL_XAIN_SELECTOR   0.5762  4.228nH 0.4783pF
1J   NC   NC
1K   NC   NC
1L   NC   NC
1M   NC   NC
1N   NC   NC
1P   NC   NC
1R   TDO   HSTL_DQ_SELECTOR   0.4825  3.8965nH   0.5399pF
2A   VSS   GND
2B   DQ27   HSTL_DQ_SELECTOR   0.5993  4.1039nH   0.9375pF
2C   NC   NC
2D   DQ29   HSTL_DQ_SELECTOR   0.6137  3.9102nH   0.9004pF
2E   NC   NC
2F   DQ30   HSTL_DQ_SELECTOR   0.6137  4.3654nH   0.9727pF
2G   DQ31   HSTL_DQ_SELECTOR   0.5889  4.1267nH   1.0948pF
2H   VREF   POWER
2J   NC   NC
2K   NC   NC
2L   DQ33   HSTL_DQ_SELECTOR   0.5519  3.3619nH   0.8709pF
2M   NC   NC
2N   DQ35   HSTL_DQ_SELECTOR   0.6267  3.6606nH   0.896pF
2P   NC   NC
2R   TCK   HSTL_XAIN_SELECTOR   0.4392  2.9847nH   0.6138pF
3A   SA   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
3B   DQ18   HSTL_DQ_SELECTOR   0.5749  3.1418nH   0.913pF
3C   DQ28   HSTL_DQ_SELECTOR   0.5490  2.7272nH   0.7035pF
3D   DQ19   HSTL_DQ_SELECTOR   0.5200  2.6346nH   0.6954pF
3E   DQ20   HSTL_DQ_SELECTOR   0.5147  2.7406nH   0.7692pF
3F   DQ21   HSTL_DQ_SELECTOR   0.5610  3.0697nH   0.8624pF
3G   DQ22   HSTL_DQ_SELECTOR   0.5453  3.0317nH   0.7978pF
3H   VDDQ   POWER
3J   DQ32   HSTL_DQ_SELECTOR   0.5597  3.0416nH   0.8177pF
3K   DQ23   HSTL_DQ_SELECTOR   0.5322  2.8051nH   0.8685pF
3L   DQ24   HSTL_DQ_SELECTOR   0.5550  2.8918nH   0.8362pF
3M   DQ34   HSTL_DQ_SELECTOR   0.5628  2.8862nH   0.7503pF
3N   DQ25   HSTL_DQ_SELECTOR   0.5346  2.7591nH   0.7796pF
3P   DQ26   HSTL_DQ_SELECTOR   0.5429  2.9451nH   0.6581pF
3R   SA   HSTL_XAIN_SELECTOR   0.4585  2.6321nH   0.6329pF
4A   R//W   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
4B   SA   HSTL_XAIN_SELECTOR   0.4439  2.5571nH   0.6406pF
4C   VSS   GND
4D   VSS   GND
4E   VDDQ   POWER
4F   VDDQ   POWER
4G   VDDQ   POWER
4H   VDDQ   POWER
4J   VDDQ   POWER
4K   VDDQ   POWER
4L   VDDQ   POWER
4M   VSS   GND
4N   VSS   GND
4P   SA   HSTL_XAIN_SELECTOR   0.4706  2.7258nH   0.626pF
4R   SA   HSTL_XAIN_SELECTOR   0.4202  2.1807nH   0.4786pF
5A   /BW2   HSTL_XAIN_SELECTOR   0.5722  3.1583nH   0.8264pF
5B   /BW3   HSTL_XAIN_SELECTOR   0.4721  2.6495nH   0.595pF
5C   SA   HSTL_XAIN_SELECTOR   0.5081  3.5996nH   0.6172pF
5D   VSS   GND
5E   VSS   GND
5F   VDD   POWER
5G   VDD   POWER
5H   VDD   POWER
5J   VDD   POWER
5K   VDD   POWER
5L   VSS   GND
5M   VSS   GND
5N   SA   HSTL_XAIN_SELECTOR   0.5101  3.1602nH   0.7321pF
5P   SA   HSTL_XAIN_SELECTOR   0.4543  2.4472nH   0.7366pF
5R   SA   HSTL_XAIN_SELECTOR   0.4352  2.1952nH   0.6288pF
6A   /K   HSTL_XAIN_SELECTOR   0.4111  2.2131nH   0.4699pF
6B   K   HSTL_XAIN_SELECTOR   0.4106  2.3306nH   0.5319pF
6C   SA0   HSTL_XAIN_SELECTOR   0.5254  3.6403nH   0.6762pF
6D   VSS   GND
6E   VSS   GND
6F   VSS   GND
6G   VSS   GND
6H   VSS   GND
6J   VSS   GND
6K   VSS   GND
6L   VSS   GND
6M   VSS   GND
6N   SA   HSTL_XAIN_SELECTOR   0.4886  2.9932nH   0.717pF
6P   C   HSTL_XAIN_SELECTOR   0.3830  2.1313nH   1.035pF
6R   /C   HSTL_XAIN_SELECTOR   0.3863  2.038nH 0.8317pF
7A   /BW1   HSTL_XAIN_SELECTOR   0.3849  1.85nH  0.5503pF
7B   /BW0   HSTL_XAIN_SELECTOR   0.4342  2.4559nH   0.5619pF
7C   SA1   HSTL_XAIN_SELECTOR   0.5330  3.7948nH   0.7261pF
7D   VSS   GND
7E   VSS   GND
7F   VDD   POWER
7G   VDD   POWER
7H   VDD   POWER
7J   VDD   POWER
7K   VDD   POWER
7L   VSS   GND
7M   VSS   GND
7N   SA   HSTL_XAIN_SELECTOR   0.4928  3.0542nH   0.722pF
7P   SA   HSTL_XAIN_SELECTOR   0.4730  2.5441nH   0.7142pF
7R   SA   HSTL_XAIN_SELECTOR   0.4260  2.1586nH   0.5587pF
8A   /LD   HSTL_XAIN_SELECTOR   0.3969  1.9968nH   0.5132pF
8B   SA   HSTL_XAIN_SELECTOR   0.4791  2.797nH 0.7324pF
8C   VSS   GND
8D   VSS   GND
8E   VDDQ   POWER
8F   VDDQ   POWER
8G   VDDQ   POWER
8H   VDDQ   POWER
8J   VDDQ   POWER
8K   VDDQ   POWER
8L   VDDQ   POWER
8M   VSS   GND
8N   VSS   GND
8P   SA   HSTL_XAIN_SELECTOR   0.4642  2.8061nH   0.6481pF
8R   SA   HSTL_XAIN_SELECTOR   0.4125  2.1537nH   0.4825pF
9A   SA   HSTL_XAIN_SELECTOR   0.4409  2.3652nH   0.5243pF
9B   NC   NC
9C   NC   NC
9D   NC   NC
9E   NC   NC
9F   NC   NC
9G   NC   NC
9H   VDDQ   POWER
9J   NC   NC
9K   NC   NC
9L   NC   NC
9M   NC   NC
9N   NC   NC
9P   NC   NC
9R   SA   HSTL_XAIN_SELECTOR   0.4425  2.4764nH   0.6482pF
10A   VSS   GND
10B   NC   NC
10C   DQ17   HSTL_DQ_SELECTOR   0.6343  4.4216nH   0.8991pF
10D   NC   NC
10E   DQ15   HSTL_DQ_SELECTOR   0.6204  4.0638nH   1.0204pF
10F   NC   NC
10G   NC   NC
10H   VREF   POWER
10J   DQ13   HSTL_DQ_SELECTOR   0.5859  3.4567nH   1.2167pF
10K   DQ12   HSTL_DQ_SELECTOR   0.5910  3.7557nH   0.9646pF
10L   NC   NC
10M   DQ11   HSTL_DQ_SELECTOR   0.5694  3.477nH 0.8106pF
10N   NC   NC
10P   DQ9   HSTL_DQ_SELECTOR   0.5759  3.5776nH   0.8543pF
10R   TMS   HSTL_XAIN_SELECTOR   0.4318  2.7023nH   0.6422pF
11A   CQ   HSTL_DQ_SELECTOR   0.5643  3.859nH 0.5208pF
11B   DQ8   HSTL_DQ_SELECTOR   0.5674  3.8866nH   0.6813pF
11C   DQ7   HSTL_DQ_SELECTOR   0.6395  4.1994nH   0.8543pF
11D   DQ16   HSTL_DQ_SELECTOR   0.5867  3.8011nH   0.7967pF
11E   DQ6   HSTL_DQ_SELECTOR   0.6400  4.1203nH   0.8725pF
11F   DQ5   HSTL_DQ_SELECTOR   0.5950  4.389nH 0.7934pF
11G   DQ14   HSTL_DQ_SELECTOR   0.6323  4.3389nH   0.8472pF
11H   ZQ   HSTL_XAIN_SELECTOR   0.6099  4.4619nH   0.4781pF
11J   DQ4   HSTL_DQ_SELECTOR   0.5882  3.9082nH   0.6089pF
11K   DQ3   HSTL_DQ_SELECTOR   0.6030  4.1177nH   0.8414pF
11L   DQ2   HSTL_DQ_SELECTOR   0.5818  3.9752nH   0.7472pF
11M   DQ1   HSTL_DQ_SELECTOR   0.5712  3.6156nH   0.8142pF
11N   DQ10   HSTL_DQ_SELECTOR   0.6075  3.9131nH   0.8497pF
11P   DQ0   HSTL_DQ_SELECTOR   0.5948  4.1522nH   1.1364pF
11R   TDI   HSTL_XAIN_SELECTOR   0.4759  3.5856nH   0.565pF
|   Component k7i321884c_165fbga
[Component]   k7i321884c_165fbga
[Manufacturer]   Samsung Electronics Co., LTD.
[Package]
| variable   typ   min(slow/weak)   max(fast/strong)
R_pkg   0.5674   0.3830   0.6400
L_pkg   3.4428nH   1.8500nH   4.5663nH
C_pkg   0.7742pF   0.4699pF   1.2167pF
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
1A   /CQ   HSTL_DQ_SELECTOR   0.5806  3.9389nH   0.6285pF
1B   NC   NC
1C   NC   NC
1D   NC   NC
1E   NC   NC
1F   NC   NC
1G   NC   NC
1H   /DOFF   HSTL_XAIN_SELECTOR   0.5762  4.228nH 0.4783pF
1J   NC   NC
1K   NC   NC
1L   NC   NC
1M   NC   NC
1N   NC   NC
1P   NC   NC
1R   TDO   HSTL_DQ_SELECTOR   0.4825  3.8965nH   0.5399pF
2A   VSS   GND
2B   DQ9   HSTL_DQ_SELECTOR   0.5993  4.1039nH   0.9375pF
2C   NC   NC
2D   NC   NC   0.6137  3.9102nH   0.9004pF
2E   NC   NC
2F   DQ12   HSTL_DQ_SELECTOR   0.6137  4.3654nH   0.9727pF
2G   NC   NC   0.5889  4.1267nH   1.0948pF
2H   VREF   POWER
2J   NC   NC
2K   NC   NC
2L   DQ15   HSTL_DQ_SELECTOR   0.5519  3.3619nH   0.8709pF
2M   NC   NC
2N   NC   NC   0.6267  3.6606nH   0.896pF
2P   NC   NC
2R   TCK   HSTL_XAIN_SELECTOR   0.4392  2.9847nH   0.6138pF
3A   SA   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
3B   NC   NC   0.5749  3.1418nH   0.913pF
3C   NC   NC   0.5490  2.7272nH   0.7035pF
3D   DQ10   HSTL_DQ_SELECTOR   0.5200  2.6346nH   0.6954pF
3E   DQ11   HSTL_DQ_SELECTOR   0.5147  2.7406nH   0.7692pF
3F   NC   NC   0.5610  3.0697nH   0.8624pF
3G   DQ13   HSTL_DQ_SELECTOR   0.5453  3.0317nH   0.7978pF
3H   VDDQ   POWER
3J   NC   NC   0.5597  3.0416nH   0.8177pF
3K   DQ14   HSTL_DQ_SELECTOR   0.5322  2.8051nH   0.8685pF
3L   NC   NC   0.5550  2.8918nH   0.8362pF
3M   NC   NC   0.5628  2.8862nH   0.7503pF
3N   DQ16   HSTL_DQ_SELECTOR   0.5346  2.7591nH   0.7796pF
3P   DQ17   HSTL_DQ_SELECTOR   0.5429  2.9451nH   0.6581pF
3R   SA   HSTL_XAIN_SELECTOR   0.4585  2.6321nH   0.6329pF
4A   R//W   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
4B   SA   HSTL_XAIN_SELECTOR   0.4439  2.5571nH   0.6406pF
4C   VSS   GND
4D   VSS   GND
4E   VDDQ   POWER
4F   VDDQ   POWER
4G   VDDQ   POWER
4H   VDDQ   POWER
4J   VDDQ   POWER
4K   VDDQ   POWER
4L   VDDQ   POWER
4M   VSS   GND
4N   VSS   GND
4P   SA   HSTL_XAIN_SELECTOR   0.4706  2.7258nH   0.626pF
4R   SA   HSTL_XAIN_SELECTOR   0.4202  2.1807nH   0.4786pF
5A   /BW1   HSTL_XAIN_SELECTOR   0.5722  3.1583nH   0.8264pF
5B   NC   NC   0.4721  2.6495nH   0.595pF
5C   SA   HSTL_XAIN_SELECTOR   0.5081  3.5996nH   0.6172pF
5D   VSS   GND
5E   VSS   GND
5F   VDD   POWER
5G   VDD   POWER
5H   VDD   POWER
5J   VDD   POWER
5K   VDD   POWER
5L   VSS   GND
5M   VSS   GND
5N   SA   HSTL_XAIN_SELECTOR   0.5101  3.1602nH   0.7321pF
5P   SA   HSTL_XAIN_SELECTOR   0.4543  2.4472nH   0.7366pF
5R   SA   HSTL_XAIN_SELECTOR   0.4352  2.1952nH   0.6288pF
6A   /K   HSTL_XAIN_SELECTOR   0.4111  2.2131nH   0.4699pF
6B   K   HSTL_XAIN_SELECTOR   0.4106  2.3306nH   0.5319pF
6C   SA0   HSTL_XAIN_SELECTOR   0.5254  3.6403nH   0.6762pF
6D   VSS   GND
6E   VSS   GND
6F   VSS   GND
6G   VSS   GND
6H   VSS   GND
6J   VSS   GND
6K   VSS   GND
6L   VSS   GND
6M   VSS   GND
6N   SA   HSTL_XAIN_SELECTOR   0.4886  2.9932nH   0.717pF
6P   C   HSTL_XAIN_SELECTOR   0.3830  2.1313nH   1.035pF
6R   /C   HSTL_XAIN_SELECTOR   0.3863  2.038nH 0.8317pF
7A   NC   NC   0.3849  1.85nH  0.5503pF
7B   /BW0   HSTL_XAIN_SELECTOR   0.4342  2.4559nH   0.5619pF
7C   SA1   HSTL_XAIN_SELECTOR   0.5330  3.7948nH   0.7261pF
7D   VSS   GND
7E   VSS   GND
7F   VDD   POWER
7G   VDD   POWER
7H   VDD   POWER
7J   VDD   POWER
7K   VDD   POWER
7L   VSS   GND
7M   VSS   GND
7N   SA   HSTL_XAIN_SELECTOR   0.4928  3.0542nH   0.722pF
7P   SA   HSTL_XAIN_SELECTOR   0.4730  2.5441nH   0.7142pF
7R   SA   HSTL_XAIN_SELECTOR   0.4260  2.1586nH   0.5587pF
8A   /LD   HSTL_XAIN_SELECTOR   0.3969  1.9968nH   0.5132pF
8B   SA   HSTL_XAIN_SELECTOR   0.4791  2.797nH 0.7324pF
8C   VSS   GND
8D   VSS   GND
8E   VDDQ   POWER
8F   VDDQ   POWER
8G   VDDQ   POWER
8H   VDDQ   POWER
8J   VDDQ   POWER
8K   VDDQ   POWER
8L   VDDQ   POWER
8M   VSS   GND
8N   VSS   GND
8P   SA   HSTL_XAIN_SELECTOR   0.4642  2.8061nH   0.6481pF
8R   SA   HSTL_XAIN_SELECTOR   0.4125  2.1537nH   0.4825pF
9A   SA   HSTL_XAIN_SELECTOR   0.4409  2.3652nH   0.5243pF
9B   NC   NC
9C   NC   NC
9D   NC   NC
9E   NC   NC
9F   NC   NC
9G   NC   NC
9H   VDDQ   POWER
9J   NC   NC
9K   NC   NC
9L   NC   NC
9M   NC   NC
9N   NC   NC
9P   NC   NC
9R   SA   HSTL_XAIN_SELECTOR   0.4425  2.4764nH   0.6482pF
10A   SA   HSTL_XAIN_SELECTOR   0.5643  3.859nH 0.5208pF
10B   NC   NC
10C   DQ7   HSTL_DQ_SELECTOR   0.6343  4.4216nH   0.8991pF
10D   NC   NC
10E   NC   NC   0.6204  4.0638nH   1.0204pF
10F   NC   NC
10G   NC   NC
10H   VREF   POWER
10J   DQ4   HSTL_DQ_SELECTOR   0.5859  3.4567nH   1.2167pF
10K   NC   HSTL_DQ_SELECTOR   0.5910  3.7557nH   0.9646pF
10L   NC   NC
10M   DQ1   HSTL_DQ_SELECTOR   0.5694  3.477nH 0.8106pF
10N   NC   NC
10P   NC   NC   0.5759  3.5776nH   0.8543pF
10R   TMS   HSTL_XAIN_SELECTOR   0.4318  2.7023nH   0.6422pF
11A   CQ   HSTL_DQ_SELECTOR   0.5643  3.859nH 0.5208pF
11B   DQ8   HSTL_DQ_SELECTOR   0.5674  3.8866nH   0.6813pF
11C   NC   NC   0.6395  4.1994nH   0.8543pF
11D   NC   NC   0.5867  3.8011nH   0.7967pF
11E   DQ6   HSTL_DQ_SELECTOR   0.6400  4.1203nH   0.8725pF
11F   DQ5   HSTL_DQ_SELECTOR   0.5950  4.389nH 0.7934pF
11G   NC   NC   0.6323  4.3389nH   0.8472pF
11H   ZQ   HSTL_XAIN_SELECTOR   0.6099  4.4619nH   0.4781pF
11J   NC   NC   0.5882  3.9082nH   0.6089pF
11K   DQ3   HSTL_DQ_SELECTOR   0.6030  4.1177nH   0.8414pF
11L   DQ2   HSTL_DQ_SELECTOR   0.5818  3.9752nH   0.7472pF
11M   NC   NC   0.5712  3.6156nH   0.8142pF
11N   NC   NC   0.6075  3.9131nH   0.8497pF
11P   DQ0   HSTL_DQ_SELECTOR   0.5948  4.1522nH   1.1364pF
11R   TDI   HSTL_XAIN_SELECTOR   0.4759  3.5856nH   0.565pF
|   Component k7i323682c_165fbga
[Component]   k7i323682c_165fbga
[Manufacturer]   Samsung Electronics Co., LTD.
[Package]
| variable   typ   min(slow/weak)   max(fast/strong)
R_pkg   0.5674   0.3830   0.6400
L_pkg   3.4428nH   1.8500nH   4.5663nH
C_pkg   0.7742pF   0.4699pF   1.2167pF
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
1A   /CQ   HSTL_DQ_SELECTOR   0.5806  3.9389nH   0.6285pF
1B   NC   NC
1C   NC   NC
1D   NC   NC
1E   NC   NC
1F   NC   NC
1G   NC   NC
1H   /DOFF   HSTL_XAIN_SELECTOR   0.5762  4.228nH 0.4783pF
1J   NC   NC
1K   NC   NC
1L   NC   NC
1M   NC   NC
1N   NC   NC
1P   NC   NC
1R   TDO   HSTL_DQ_SELECTOR   0.4825  3.8965nH   0.5399pF
2A   VSS   GND
2B   DQ27   HSTL_DQ_SELECTOR   0.5993  4.1039nH   0.9375pF
2C   NC   NC
2D   DQ29   HSTL_DQ_SELECTOR   0.6137  3.9102nH   0.9004pF
2E   NC   NC
2F   DQ30   HSTL_DQ_SELECTOR   0.6137  4.3654nH   0.9727pF
2G   DQ31   HSTL_DQ_SELECTOR   0.5889  4.1267nH   1.0948pF
2H   VREF   POWER
2J   NC   NC
2K   NC   NC
2L   DQ33   HSTL_DQ_SELECTOR   0.5519  3.3619nH   0.8709pF
2M   NC   NC
2N   DQ35   HSTL_DQ_SELECTOR   0.6267  3.6606nH   0.896pF
2P   NC   NC
2R   TCK   HSTL_XAIN_SELECTOR   0.4392  2.9847nH   0.6138pF
3A   SA   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
3B   DQ18   HSTL_DQ_SELECTOR   0.5749  3.1418nH   0.913pF
3C   DQ28   HSTL_DQ_SELECTOR   0.5490  2.7272nH   0.7035pF
3D   DQ19   HSTL_DQ_SELECTOR   0.5200  2.6346nH   0.6954pF
3E   DQ20   HSTL_DQ_SELECTOR   0.5147  2.7406nH   0.7692pF
3F   DQ21   HSTL_DQ_SELECTOR   0.5610  3.0697nH   0.8624pF
3G   DQ22   HSTL_DQ_SELECTOR   0.5453  3.0317nH   0.7978pF
3H   VDDQ   POWER
3J   DQ32   HSTL_DQ_SELECTOR   0.5597  3.0416nH   0.8177pF
3K   DQ23   HSTL_DQ_SELECTOR   0.5322  2.8051nH   0.8685pF
3L   DQ24   HSTL_DQ_SELECTOR   0.5550  2.8918nH   0.8362pF
3M   DQ34   HSTL_DQ_SELECTOR   0.5628  2.8862nH   0.7503pF
3N   DQ25   HSTL_DQ_SELECTOR   0.5346  2.7591nH   0.7796pF
3P   DQ26   HSTL_DQ_SELECTOR   0.5429  2.9451nH   0.6581pF
3R   SA   HSTL_XAIN_SELECTOR   0.4585  2.6321nH   0.6329pF
4A   R//W   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
4B   SA   HSTL_XAIN_SELECTOR   0.4439  2.5571nH   0.6406pF
4C   VSS   GND
4D   VSS   GND
4E   VDDQ   POWER
4F   VDDQ   POWER
4G   VDDQ   POWER
4H   VDDQ   POWER
4J   VDDQ   POWER
4K   VDDQ   POWER
4L   VDDQ   POWER
4M   VSS   GND
4N   VSS   GND
4P   SA   HSTL_XAIN_SELECTOR   0.4706  2.7258nH   0.626pF
4R   SA   HSTL_XAIN_SELECTOR   0.4202  2.1807nH   0.4786pF
5A   /BW2   HSTL_XAIN_SELECTOR   0.5722  3.1583nH   0.8264pF
5B   /BW3   HSTL_XAIN_SELECTOR   0.4721  2.6495nH   0.595pF
5C   SA   HSTL_XAIN_SELECTOR   0.5081  3.5996nH   0.6172pF
5D   VSS   GND
5E   VSS   GND
5F   VDD   POWER
5G   VDD   POWER
5H   VDD   POWER
5J   VDD   POWER
5K   VDD   POWER
5L   VSS   GND
5M   VSS   GND
5N   SA   HSTL_XAIN_SELECTOR   0.5101  3.1602nH   0.7321pF
5P   SA   HSTL_XAIN_SELECTOR   0.4543  2.4472nH   0.7366pF
5R   SA   HSTL_XAIN_SELECTOR   0.4352  2.1952nH   0.6288pF
6A   /K   HSTL_XAIN_SELECTOR   0.4111  2.2131nH   0.4699pF
6B   K   HSTL_XAIN_SELECTOR   0.4106  2.3306nH   0.5319pF
6C   SA0   HSTL_XAIN_SELECTOR   0.5254  3.6403nH   0.6762pF
6D   VSS   GND
6E   VSS   GND
6F   VSS   GND
6G   VSS   GND
6H   VSS   GND
6J   VSS   GND
6K   VSS   GND
6L   VSS   GND
6M   VSS   GND
6N   SA   HSTL_XAIN_SELECTOR   0.4886  2.9932nH   0.717pF
6P   C   HSTL_XAIN_SELECTOR   0.3830  2.1313nH   1.035pF
6R   /C   HSTL_XAIN_SELECTOR   0.3863  2.038nH 0.8317pF
7A   /BW1   HSTL_XAIN_SELECTOR   0.3849  1.85nH  0.5503pF
7B   /BW0   HSTL_XAIN_SELECTOR   0.4342  2.4559nH   0.5619pF
7C   SA1   HSTL_XAIN_SELECTOR   0.5330  3.7948nH   0.7261pF
7D   VSS   GND
7E   VSS   GND
7F   VDD   POWER
7G   VDD   POWER
7H   VDD   POWER
7J   VDD   POWER
7K   VDD   POWER
7L   VSS   GND
7M   VSS   GND
7N   SA   HSTL_XAIN_SELECTOR   0.4928  3.0542nH   0.722pF
7P   SA   HSTL_XAIN_SELECTOR   0.4730  2.5441nH   0.7142pF
7R   SA   HSTL_XAIN_SELECTOR   0.4260  2.1586nH   0.5587pF
8A   /LD   HSTL_XAIN_SELECTOR   0.3969  1.9968nH   0.5132pF
8B   SA   HSTL_XAIN_SELECTOR   0.4791  2.797nH 0.7324pF
8C   VSS   GND
8D   VSS   GND
8E   VDDQ   POWER
8F   VDDQ   POWER
8G   VDDQ   POWER
8H   VDDQ   POWER
8J   VDDQ   POWER
8K   VDDQ   POWER
8L   VDDQ   POWER
8M   VSS   GND
8N   VSS   GND
8P   SA   HSTL_XAIN_SELECTOR   0.4642  2.8061nH   0.6481pF
8R   SA   HSTL_XAIN_SELECTOR   0.4125  2.1537nH   0.4825pF
9A   SA   HSTL_XAIN_SELECTOR   0.4409  2.3652nH   0.5243pF
9B   NC   NC
9C   NC   NC
9D   NC   NC
9E   NC   NC
9F   NC   NC
9G   NC   NC
9H   VDDQ   POWER
9J   NC   NC
9K   NC   NC
9L   NC   NC
9M   NC   NC
9N   NC   NC
9P   NC   NC
9R   SA   HSTL_XAIN_SELECTOR   0.4425  2.4764nH   0.6482pF
10A   VSS   GND
10B   NC   NC
10C   DQ17   HSTL_DQ_SELECTOR   0.6343  4.4216nH   0.8991pF
10D   NC   NC
10E   DQ15   HSTL_DQ_SELECTOR   0.6204  4.0638nH   1.0204pF
10F   NC   NC
10G   NC   NC
10H   VREF   POWER
10J   DQ13   HSTL_DQ_SELECTOR   0.5859  3.4567nH   1.2167pF
10K   DQ12   HSTL_DQ_SELECTOR   0.5910  3.7557nH   0.9646pF
10L   NC   NC
10M   DQ11   HSTL_DQ_SELECTOR   0.5694  3.477nH 0.8106pF
10N   NC   NC
10P   DQ9   HSTL_DQ_SELECTOR   0.5759  3.5776nH   0.8543pF
10R   TMS   HSTL_XAIN_SELECTOR   0.4318  2.7023nH   0.6422pF
11A   CQ   HSTL_DQ_SELECTOR   0.5643  3.859nH 0.5208pF
11B   DQ8   HSTL_DQ_SELECTOR   0.5674  3.8866nH   0.6813pF
11C   DQ7   HSTL_DQ_SELECTOR   0.6395  4.1994nH   0.8543pF
11D   DQ16   HSTL_DQ_SELECTOR   0.5867  3.8011nH   0.7967pF
11E   DQ6   HSTL_DQ_SELECTOR   0.6400  4.1203nH   0.8725pF
11F   DQ5   HSTL_DQ_SELECTOR   0.5950  4.389nH 0.7934pF
11G   DQ14   HSTL_DQ_SELECTOR   0.6323  4.3389nH   0.8472pF
11H   ZQ   HSTL_XAIN_SELECTOR   0.6099  4.4619nH   0.4781pF
11J   DQ4   HSTL_DQ_SELECTOR   0.5882  3.9082nH   0.6089pF
11K   DQ3   HSTL_DQ_SELECTOR   0.6030  4.1177nH   0.8414pF
11L   DQ2   HSTL_DQ_SELECTOR   0.5818  3.9752nH   0.7472pF
11M   DQ1   HSTL_DQ_SELECTOR   0.5712  3.6156nH   0.8142pF
11N   DQ10   HSTL_DQ_SELECTOR   0.6075  3.9131nH   0.8497pF
11P   DQ0   HSTL_DQ_SELECTOR   0.5948  4.1522nH   1.1364pF
11R   TDI   HSTL_XAIN_SELECTOR   0.4759  3.5856nH   0.565pF
|   Component k7i321882c_165fbga
[Component]   k7i321882c_165fbga
[Manufacturer]   Samsung Electronics Co., LTD.
[Package]
| variable   typ   min(slow/weak)   max(fast/strong)
R_pkg   0.5674   0.3830   0.6400
L_pkg   3.4428nH   1.8500nH   4.5663nH
C_pkg   0.7742pF   0.4699pF   1.2167pF
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
1A   /CQ   HSTL_DQ_SELECTOR   0.5806  3.9389nH   0.6285pF
1B   NC   NC
1C   NC   NC
1D   NC   NC
1E   NC   NC
1F   NC   NC
1G   NC   NC
1H   /DOFF   HSTL_XAIN_SELECTOR   0.5762  4.228nH 0.4783pF
1J   NC   NC
1K   NC   NC
1L   NC   NC
1M   NC   NC
1N   NC   NC
1P   NC   NC
1R   TDO   HSTL_DQ_SELECTOR   0.4825  3.8965nH   0.5399pF
2A   VSS   GND
2B   DQ9   HSTL_DQ_SELECTOR   0.5993  4.1039nH   0.9375pF
2C   NC   NC
2D   NC   NC   0.6137  3.9102nH   0.9004pF
2E   NC   NC
2F   DQ12   HSTL_DQ_SELECTOR   0.6137  4.3654nH   0.9727pF
2G   NC   NC   0.5889  4.1267nH   1.0948pF
2H   VREF   POWER
2J   NC   NC
2K   NC   NC
2L   DQ15   HSTL_DQ_SELECTOR   0.5519  3.3619nH   0.8709pF
2M   NC   NC
2N   NC   NC   0.6267  3.6606nH   0.896pF
2P   NC   NC
2R   TCK   HSTL_XAIN_SELECTOR   0.4392  2.9847nH   0.6138pF
3A   SA   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
3B   NC   NC   0.5749  3.1418nH   0.913pF
3C   NC   NC   0.5490  2.7272nH   0.7035pF
3D   DQ10   HSTL_DQ_SELECTOR   0.5200  2.6346nH   0.6954pF
3E   DQ11   HSTL_DQ_SELECTOR   0.5147  2.7406nH   0.7692pF
3F   NC   NC   0.5610  3.0697nH   0.8624pF
3G   DQ13   HSTL_DQ_SELECTOR   0.5453  3.0317nH   0.7978pF
3H   VDDQ   POWER
3J   NC   NC   0.5597  3.0416nH   0.8177pF
3K   DQ14   HSTL_DQ_SELECTOR   0.5322  2.8051nH   0.8685pF
3L   NC   NC   0.5550  2.8918nH   0.8362pF
3M   NC   NC   0.5628  2.8862nH   0.7503pF
3N   DQ16   HSTL_DQ_SELECTOR   0.5346  2.7591nH   0.7796pF
3P   DQ17   HSTL_DQ_SELECTOR   0.5429  2.9451nH   0.6581pF
3R   SA   HSTL_XAIN_SELECTOR   0.4585  2.6321nH   0.6329pF
4A   R//W   HSTL_XAIN_SELECTOR   0.3846  2.0626nH   0.4865pF
4B   SA   HSTL_XAIN_SELECTOR   0.4439  2.5571nH   0.6406pF
4C   VSS   GND
4D   VSS   GND
4E   VDDQ   POWER
4F   VDDQ   POWER
4G   VDDQ   POWER
4H   VDDQ   POWER
4J   VDDQ   POWER
4K   VDDQ   POWER
4L   VDDQ   POWER
4M   VSS   GND
4N   VSS   GND
4P   SA   HSTL_XAIN_SELECTOR   0.4706  2.7258nH   0.626pF
4R   SA   HSTL_XAIN_SELECTOR   0.4202  2.1807nH   0.4786pF
5A   /BW1   HSTL_XAIN_SELECTOR   0.5722  3.1583nH   0.8264pF
5B   NC   NC   0.4721  2.6495nH   0.595pF
5C   SA   HSTL_XAIN_SELECTOR   0.5081  3.5996nH   0.6172pF
5D   VSS   GND
5E   VSS   GND
5F   VDD   POWER
5G   VDD   POWER
5H   VDD   POWER
5J   VDD   POWER
5K   VDD   POWER
5L   VSS   GND
5M   VSS   GND
5N   SA   HSTL_XAIN_SELECTOR   0.5101  3.1602nH   0.7321pF
5P   SA   HSTL_XAIN_SELECTOR   0.4543  2.4472nH   0.7366pF
5R   SA   HSTL_XAIN_SELECTOR   0.4352  2.1952nH   0.6288pF
6A   /K   HSTL_XAIN_SELECTOR   0.4111  2.2131nH   0.4699pF
6B   K   HSTL_XAIN_SELECTOR   0.4106  2.3306nH   0.5319pF
6C   SA0   HSTL_XAIN_SELECTOR   0.5254  3.6403nH   0.6762pF
6D   VSS   GND
6E   VSS   GND
6F   VSS   GND
6G   VSS   GND
6H   VSS   GND
6J   VSS   GND
6K   VSS   GND
6L   VSS   GND
6M   VSS   GND
6N   SA   HSTL_XAIN_SELECTOR   0.4886  2.9932nH   0.717pF
6P   C   HSTL_XAIN_SELECTOR   0.3830  2.1313nH   1.035pF
6R   /C   HSTL_XAIN_SELECTOR   0.3863  2.038nH 0.8317pF
7A   NC   NC   0.3849  1.85nH  0.5503pF
7B   /BW0   HSTL_XAIN_SELECTOR   0.4342  2.4559nH   0.5619pF
7C   SA1   HSTL_XAIN_SELECTOR   0.5330  3.7948nH   0.7261pF
7D   VSS   GND
7E   VSS   GND
7F   VDD   POWER
7G   VDD   POWER
7H   VDD   POWER
7J   VDD   POWER
7K   VDD   POWER
7L   VSS   GND
7M   VSS   GND
7N   SA   HSTL_XAIN_SELECTOR   0.4928  3.0542nH   0.722pF
7P   SA   HSTL_XAIN_SELECTOR   0.4730  2.5441nH   0.7142pF
7R   SA   HSTL_XAIN_SELECTOR   0.4260  2.1586nH   0.5587pF
8A   /LD   HSTL_XAIN_SELECTOR   0.3969  1.9968nH   0.5132pF
8B   SA   HSTL_XAIN_SELECTOR   0.4791  2.797nH 0.7324pF
8C   VSS   GND
8D   VSS   GND
8E   VDDQ   POWER
8F   VDDQ   POWER
8G   VDDQ   POWER
8H   VDDQ   POWER
8J   VDDQ   POWER
8K   VDDQ   POWER
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| Models and submodels in the file (16): 32MC_HSTL_DIN15 (Input), 32MC_HSTL_DQ15_40 (I/O), 32MC_HSTL_DQ15_50 (I/O), 32MC_HSTL_DQ15_60 (I/O), 32MC_HSTL_OUT15_40 (Output), 32MC_HSTL_OUT15_50 (Output), 32MC_HSTL_OUT15_60 (Output), 32MC_HSTL_XAIN15 (Input), 32MC_HSTL_DIN18 (Input), 32MC_HSTL_DQ18_40 (I/O), 32MC_HSTL_DQ18_50 (I/O), 32MC_HSTL_DQ18_60 (I/O), 32MC_HSTL_OUT18_40 (Output), 32MC_HSTL_OUT18_50 (Output), 32MC_HSTL_OUT18_60 (Output), 32MC_HSTL_XAIN18 (Input)
